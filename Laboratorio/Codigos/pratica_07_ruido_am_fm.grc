options:
  parameters:
    author: Prof. Daniel Costa Araújo
    description: Prática 07 - Ruído em Demoduladores AM e FM
    generate_options: qt_gui
    id: pratica_07_ruido_am_fm
    output_language: python
    title: Prática 07 - Ruído em Demoduladores AM e FM
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Taxa de amostragem (FM)
    value: '480000'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    comment: Taxa de amostragem (áudio/AM)
    value: '48000'
  states: {}
- name: fc
  id: variable
  parameters:
    comment: Frequência da portadora
    value: '10000'
  states: {}
- name: fm
  id: variable
  parameters:
    comment: Frequência da mensagem
    value: '1000'
  states: {}
- name: max_dev
  id: variable
  parameters:
    comment: Desvio máximo de frequência FM
    value: '10000'
  states: {}
- name: noise_sigma
  id: variable_qtgui_range
  parameters:
    comment: Amplitude do ruído AWGN
    gui_hint: 0,0,1,2
    label: Noise Sigma
    start: '0'
    step: '0.05'
    stop: '1.0'
    value: '0'
  states: {}
- name: src_mensagem_am
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    comment: Sinal mensagem AM m(t)
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: src_portadora_am
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    comment: Portadora AM c(t)
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: src_local_am
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    comment: Oscilador local AM (demod)
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: mult_mod_am
  id: blocks_multiply_xx
  parameters:
    comment: 'Modulação AM DSB-SC: m(t) × c(t)'
    type: float
  states: {}
- name: noise_am
  id: analog_noise_source_x
  parameters:
    amp: noise_sigma
    comment: Ruído AWGN (AM)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: add_am
  id: blocks_add_xx
  parameters:
    comment: AM + ruído
    type: float
  states: {}
- name: mult_demod_am
  id: blocks_multiply_xx
  parameters:
    comment: 'Demodulação AM: r(t) × cos(2πfc·t)'
    type: float
  states: {}
- name: lpf_am
  id: low_pass_filter
  parameters:
    comment: Filtro passa-baixas AM
    cutoff_freq: '1500'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: throttle_am
  id: blocks_throttle2
  parameters:
    comment: Throttle AM
    samples_per_second: audio_rate
    type: float
  states: {}
- name: src_mensagem_fm
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    comment: Sinal mensagem FM m(t)
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: wfm_tx
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    comment: Modulador WBFM
    fh: '-1.0'
    max_dev: max_dev
    quad_rate: samp_rate
    tau: '0'
  states: {}
- name: throttle_fm
  id: blocks_throttle2
  parameters:
    comment: Throttle FM
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: noise_fm
  id: analog_noise_source_x
  parameters:
    amp: noise_sigma
    comment: Ruído AWGN (FM, Complex)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: add_fm
  id: blocks_add_xx
  parameters:
    comment: FM + ruído
    type: complex
  states: {}
- name: wfm_rcv
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    comment: Demodulador WBFM
    quad_rate: samp_rate
  states: {}
- name: time_sink
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 2,0,1,2
    label1: Mensagem original
    label2: AM demodulado
    label3: FM demodulado
    name: '"Comparação AM vs FM"'
    nconnections: '3'
    size: '1024'
    srate: audio_rate
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [src_mensagem_am, '0', mult_mod_am, '0']
- [src_portadora_am, '0', mult_mod_am, '1']
- [mult_mod_am, '0', add_am, '0']
- [noise_am, '0', add_am, '1']
- [add_am, '0', mult_demod_am, '0']
- [src_local_am, '0', mult_demod_am, '1']
- [mult_demod_am, '0', lpf_am, '0']
- [lpf_am, '0', throttle_am, '0']
- [src_mensagem_fm, '0', wfm_tx, '0']
- [wfm_tx, '0', throttle_fm, '0']
- [throttle_fm, '0', add_fm, '0']
- [noise_fm, '0', add_fm, '1']
- [add_fm, '0', wfm_rcv, '0']
- [src_mensagem_am, '0', time_sink, '0']
- [throttle_am, '0', time_sink, '1']
- [wfm_rcv, '0', time_sink, '2']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
