options:
  parameters:
    author: Prof. Daniel Costa Araújo
    description: Prática 06 - Phase-Locked Loop (PLL)
    generate_options: qt_gui
    id: pratica_06_pll
    output_language: python
    title: Prática 06 - Phase-Locked Loop (PLL)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Taxa de amostragem
    value: '32000'
  states: {}
- name: max_freq
  id: variable
  parameters:
    comment: Frequência máxima do PLL (rad/amostra)
    value: 2*3.14159265*2000/samp_rate
  states: {}
- name: min_freq
  id: variable
  parameters:
    comment: Frequência mínima do PLL (rad/amostra)
    value: '-max_freq'
  states: {}
- name: loop_bw
  id: variable_qtgui_range
  parameters:
    comment: Largura de banda do laço (rad/amostra)
    gui_hint: 0,0,1,1
    label: Loop Bandwidth (rad/amostra)
    start: '0.01'
    step: '0.01'
    stop: '0.628'
    value: '0.062'
  states: {}
- name: freq_in
  id: variable_qtgui_range
  parameters:
    comment: Frequência do sinal de entrada (Hz)
    gui_hint: 0,1,1,1
    label: Frequência de entrada (Hz)
    start: '200'
    step: '50'
    stop: '1800'
    value: '1000'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    comment: Amplitude do ruído gaussiano
    gui_hint: 1,0,1,1
    label: Amplitude do Ruído
    start: '0'
    step: '0.05'
    stop: '1.0'
    value: '0'
  states: {}
- name: src_signal
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    comment: Sinal de entrada complexo
    freq: freq_in
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: src_noise
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    comment: Ruído gaussiano complexo
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: add_block
  id: blocks_add_xx
  parameters:
    comment: Sinal + Ruído
    type: complex
  states: {}
- name: pll_freqdet
  id: analog_pll_freqdet_cf
  parameters:
    comment: PLL Frequency Detector
    freq: loop_bw
    max_freq: max_freq
    min_freq: min_freq
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: time_sink
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: Saída PLL (frequência)
    name: '"Convergência do PLL"'
    size: '4096'
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: freq_sink_entrada
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 2,1,1,1
    label1: Sinal de entrada
    name: '"Espectro do Sinal de Entrada"'
    type: complex
    wintype: window.WIN_HANN
    ymin: '-100'
  states: {}

connections:
- [src_signal, '0', add_block, '0']
- [src_noise, '0', add_block, '1']
- [add_block, '0', pll_freqdet, '0']
- [pll_freqdet, '0', throttle, '0']
- [throttle, '0', time_sink, '0']
- [add_block, '0', freq_sink_entrada, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
