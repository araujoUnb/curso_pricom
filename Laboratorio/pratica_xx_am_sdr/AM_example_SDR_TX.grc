options:
  parameters:
    generate_options: qt_gui
    id: AM_example_SDR_TX
    output_language: python
    title: AM_example_SDR_TX
  states: {}

blocks:
- name: cut_freq
  id: variable
  parameters:
    value: 18e3
  states: {}
- name: mod_type
  id: variable_qtgui_chooser
  parameters:
    label: Tipo de modulacao AM
    labels: '[''AM c/ portadora (DSB-TC)'', ''DSB-SC'', ''VSB'', ''SSB'']'
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    options: '[0, 1, 2, 3]'
    type: int
    value: '3'
  states: {}
- name: mult_DSB_LC
  id: variable_qtgui_range
  parameters:
    start: '0.3'
    step: '0.1'
    stop: '1.5'
    value: '0.8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: trans_width
  id: variable
  parameters:
    value: 2e3
  states: {}
- name: tx_lo_freq
  id: variable
  parameters:
    value: int(1e9)
  states: {}
- name: tx_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: cut_freq
    gain: '20'
    samp_rate: samp_rate*20
    width: trans_width
    win: window.WIN_HAMMING
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-2'
    decay_rate: '1e-3'
    gain: '1.0'
    max_gain: '100'
    reference: '0.8'
    type: float
  states: {}
- name: analog_probe_avg_mag_sqrd_x_0
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '1e-4'
    threshold: '0'
    type: cf
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-(cut_freq/2)'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: cut_freq/2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: cut_freq/2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-cut_freq/2'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mult_DSB_LC
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: mod_type
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ./audio/rock_mono_48kHz.wav
    repeat: 'True'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: tx_lo_freq
    samplerate: samp_rate*20
    type: fc32
    uri: uri
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '20'
    taps: tx_taps
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_freq/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: trans_width*2
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_freq/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: trans_width/2
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: audio original
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    label1: DSB-LC
    label2: DSB-SC
    label3: VSB
    label4: SSB USB
    nconnections: '4'
    type: complex
    wintype: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    label1: audio modulado TX
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Potência de Transmissão (dB)
    max: '20'
    min: '-80'
    name: Estimação (dB)
    type: float
  states: {}
- name: uri
  id: parameter
  parameters:
    label: URI
    type: str
    value: ip:192.168.1.10
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: DSB-LC_Mod
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: DSB-SC_Mod
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: VSB_Mod
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: SSB_Mod
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: original
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: DSB-LC_Mod
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: DSB-SC_Mod
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: VSB_Mod
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: SSB_Mod
  states: {}
- name: virtual_source_0_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: SSB_Mod
  states: {state: disabled}
- name: virtual_source_0_0_0_2
  id: virtual_source
  parameters:
    stream_id: VSB_Mod
  states: {state: disabled}
- name: virtual_source_0_0_2
  id: virtual_source
  parameters:
    stream_id: DSB-SC_Mod
  states: {}
- name: virtual_source_0_0_2_0
  id: virtual_source
  parameters:
    stream_id: DSB-SC_Mod
  states: {}
- name: virtual_source_0_0_3
  id: virtual_source
  parameters:
    stream_id: DSB-SC_Mod
  states: {state: disabled}
- name: virtual_source_0_4
  id: virtual_source
  parameters:
    stream_id: DSB-LC_Mod
  states: {state: disabled}
- name: virtual_source_0_4_0
  id: virtual_source
  parameters:
    stream_id: original
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_float_to_complex_0, '0']
- [analog_agc2_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_probe_avg_mag_sqrd_x_0, '0', blocks_nlog10_ff_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0_0, '1']
- [analog_sig_source_x_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0_0, '1']
- [analog_sig_source_x_0_0_1, '0', blocks_multiply_xx_0_0_0_1, '1']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_float_to_complex_0, '0', virtual_sink_0_0, '0']
- [blocks_float_to_complex_0_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0_0_0, '0', virtual_sink_0_0_0, '0']
- [blocks_multiply_xx_0_0_0_0_0, '0', virtual_sink_0_0_0_0, '0']
- [blocks_multiply_xx_0_0_0_1, '0', low_pass_filter_0_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_selector_1, '0', interp_fir_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', analog_agc2_xx_0, '0']
- [blocks_wavfile_source_0, '0', virtual_sink_0_1, '0']
- [interp_fir_filter_xxx_0, '0', analog_probe_avg_mag_sqrd_x_0, '0']
- [interp_fir_filter_xxx_0, '0', iio_pluto_sink_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0_0_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_xx_0_0_0_0_0, '0']
- [virtual_source_0, '0', blocks_selector_1, '0']
- [virtual_source_0_0, '0', blocks_selector_1, '1']
- [virtual_source_0_0_0, '0', blocks_selector_1, '2']
- [virtual_source_0_0_0_0, '0', blocks_selector_1, '3']
- [virtual_source_0_0_0_0_1, '0', qtgui_freq_sink_x_0_0, '3']
- [virtual_source_0_0_0_2, '0', qtgui_freq_sink_x_0_0, '2']
- [virtual_source_0_0_2, '0', blocks_multiply_xx_0_0_0, '0']
- [virtual_source_0_0_2_0, '0', blocks_multiply_xx_0_0_0_1, '0']
- [virtual_source_0_0_3, '0', qtgui_freq_sink_x_0_0, '1']
- [virtual_source_0_4, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0_4_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
