options:
  parameters:
    generate_options: qt_gui
    id: AM_example_SDR
    output_language: python
    title: AM_example_SDR
  states: {}

blocks:
- name: capture_freq
  id: variable_qtgui_range
  parameters:
    start: '100'
    step: '1'
    stop: '1000'
    value: '200'
  states: {}
- name: cut_freq
  id: variable
  parameters:
    value: 18e3
  states: {}
- name: gain_audio
  id: variable_qtgui_range
  parameters:
    start: '0.5'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: mod_type
  id: variable_qtgui_chooser
  parameters:
    label: Tipo de modulacao AM
    labels: '[''AM c/ portadora (DSB-TC)'', ''DSB-SC'', ''VSB'', ''SSB'']'
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    options: '[0, 1, 2, 3]'
    type: int
    value: '3'
  states: {}
- name: offset
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: rx_lo_freq
  id: variable
  parameters:
    value: int(tx_lo_freq - offset)
  states: {}
- name: rx_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: cut_freq
    gain: '1'
    samp_rate: samp_rate*20
    width: trans_width
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: trans_width
  id: variable
  parameters:
    value: 2e3
  states: {}
- name: tx_lo_freq
  id: variable
  parameters:
    value: int(1e9)
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: (2*pi*capture_freq)/samp_rate
    min_freq: '-(2*pi*capture_freq)/samp_rate'
    w: '0.02'
  states: {}
- name: analog_probe_avg_mag_sqrd_x_noise
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '1e-4'
    threshold: '0'
    type: cf
  states: {}
- name: analog_probe_avg_mag_sqrd_x_sig
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '1e-4'
    threshold: '0'
    type: cf
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_noise
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 170e3
    low_cutoff_freq: 130e3
    samp_rate: samp_rate*20
    type: fir_filter_ccf
    width: trans_width
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_sig
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: offset+20e3
    low_cutoff_freq: offset-20e3
    samp_rate: samp_rate*20
    type: fir_filter_ccf
    width: trans_width
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_audio
    type: float
  states: {}
- name: blocks_nlog10_ff_noise
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_sig
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: mod_type
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '20'
    taps: rx_taps
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '20'
    taps: rx_taps
    type: ccc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: rx_lo_freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate*20
    type: fc32
    uri: uri
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from numpy import pi
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_freq
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: trans_width
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    label1: audio recuperado
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    label1: audio modulado RX
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Potência Recebida (dB)
    label2: SNR (dB)
    label3: Potência do Ruído (dB)
    max: '60'
    min: '-10'
    name: Estimação (dB)
    nconnections: '3'
    type: float
  states: {}
- name: uri
  id: parameter
  parameters:
    label: URI
    type: str
    value: ip:192.168.1.10
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: DSB-LC_Demod
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: DSB-SC_Demod
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: VSB_Demod
  states: {}
- name: virtual_sink_1_0_1
  id: virtual_sink
  parameters:
    stream_id: SSB_Demod
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: sig_received
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: sig_received
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: SSB_Demod
  states: {}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: VSB_Demod
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: DSB-SC_Demod
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: DSB-LC_Demod
  states: {}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: sig_received
  states: {}

connections:
- [analog_pll_refout_cc_0, '0', fir_filter_xxx_0, '0']
- [analog_probe_avg_mag_sqrd_x_noise, '0', blocks_nlog10_ff_noise, '0']
- [analog_probe_avg_mag_sqrd_x_sig, '0', blocks_nlog10_ff_sig, '0']
- [band_pass_filter_noise, '0', analog_probe_avg_mag_sqrd_x_noise, '0']
- [band_pass_filter_sig, '0', analog_probe_avg_mag_sqrd_x_sig, '0']
- [blocks_complex_to_mag_0, '0', low_pass_filter_0, '0']
- [blocks_complex_to_real_0, '0', virtual_sink_1_0, '0']
- [blocks_complex_to_real_0, '0', virtual_sink_1_0_0, '0']
- [blocks_complex_to_real_0, '0', virtual_sink_1_0_1, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_nlog10_ff_noise, '0', blocks_sub_xx_0, '1']
- [blocks_nlog10_ff_noise, '0', qtgui_number_sink_0, '2']
- [blocks_nlog10_ff_sig, '0', blocks_sub_xx_0, '0']
- [blocks_nlog10_ff_sig, '0', qtgui_number_sink_0, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_sub_xx_0, '0', qtgui_number_sink_0, '1']
- [dc_blocker_xx_0, '0', virtual_sink_1, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_real_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_complex_to_mag_0, '0']
- [iio_pluto_source_0, '0', analog_pll_refout_cc_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [iio_pluto_source_0, '0', virtual_sink_1_1, '0']
- [low_pass_filter_0, '0', dc_blocker_xx_0, '0']
- [virtual_source_0, '0', band_pass_filter_noise, '0']
- [virtual_source_0, '0', band_pass_filter_sig, '0']
- [virtual_source_0_0_0_0_0, '0', blocks_selector_0, '3']
- [virtual_source_0_0_0_1, '0', blocks_selector_0, '2']
- [virtual_source_0_0_1, '0', blocks_selector_0, '1']
- [virtual_source_0_2, '0', blocks_selector_0, '0']
- [virtual_source_0_2_0, '0', fir_filter_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
