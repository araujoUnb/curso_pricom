options:
  parameters:
    author: bismark
    generate_options: qt_gui
    id: AM_SDR_RX
    output_language: python
    title: AM SDR RX
  states: {}

blocks:
- name: cut_freq
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: expected_freq_pll
  id: variable
  parameters:
    value: 2e3
  states: {}
- name: fc
  id: variable
  parameters:
    value: int(1e9)
  states: {}
- name: fc_rx
  id: variable
  parameters:
    value: int(fc - offset)
  states: {}
- name: loop_bandwidth_pll
  id: variable_qtgui_range
  parameters:
    start: '0.0001'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
  states: {}
- name: offset
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: rx_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: cut_freq-transition_width
    gain: '1'
    samp_rate: samp_rate*20
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: set_mod_rx
  id: variable_qtgui_chooser
  parameters:
    label: Tipo de modulacao AM RX
    label0: Com portadora
    label1: Sem portadora Com PLL
    label2: Sem portadora Sem PLL
    labels: '[''AM c/ portadora (DSB-TC)'', ''DSB-SC'', ''VSB'', ''SSB'']'
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    options: '[0, 1, 2, 3]'
    type: int
    value: '0'
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '0.5'
    stop: '10'
    value: '1'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: (2*pi*expected_freq_pll)/samp_rate
    min_freq: '-(2*pi*expected_freq_pll)/samp_rate'
    w: loop_bandwidth_pll
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*20
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: Detector Envelope
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters:
    comment: Detector de Produto
  states: {}
- name: blocks_complex_to_real_0_0_0_0
  id: blocks_complex_to_real
  parameters:
    comment: Detector de Produto
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: set_mod_rx
    type: complex
  states: {}
- name: blocks_selector_3_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: set_mod_rx
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Desenrola a fase e divide por 2 (recuperacao de portadora via quadrado)"""
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Unwrap e Divide por 2',
                  in_sig=[np.complex64],   # saida do PLL Carrier Regeneration (em 2*theta)
                  out_sig=[np.complex64]   # portadora reconstruida (em theta)
              )
              self.fase_anterior = 0.0
              self.acumulado = 0.0

          def work(self, input_items, output_items):
              x = input_items[0]
              y = output_items[0]
              fase_ant = self.fase_anterior
              acumulado = self.acumulado

              for n in range(len(x)):
                  fase_bruta = np.angle(x[n])
                  diferenca = fase_bruta - fase_ant

                  if diferenca > np.pi:
                      acumulado -= 2*np.pi
                  elif diferenca < -np.pi:
                      acumulado += 2*np.pi

                  fase_continua = fase_bruta + acumulado
                  fase_ant = fase_bruta

                  theta = fase_continua / 2.0
                  y[n] = np.exp(1j*theta)

              self.fase_anterior = fase_ant
              self.acumulado = acumulado
              return len(output_items[0])
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '20'
    taps: rx_taps
    type: ccc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: fc_rx
    gain1: '''fast_attack'''
    manual_gain1: '30'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate*20
    type: fc32
    uri: uri
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from numpy import pi
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_freq-transition_width
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    label1: mensagem recuperada
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: uri
  id: parameter
  parameters:
    label: URI
    type: str
    value: ip:192.168.1.10
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Carrier
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: No_Carrier_No_PLL
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: No_Carrier_PLL
  states: {}
- name: virtual_source_1_1_0_0
  id: virtual_source
  parameters:
    stream_id: No_Carrier_PLL
  states: {}
- name: virtual_source_1_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: No_Carrier_No_PLL
  states: {}
- name: virtual_source_1_1_0_0_1
  id: virtual_source
  parameters:
    stream_id: Carrier
  states: {}

connections:
- [analog_pll_refout_cc_0, '0', epy_block_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_0, '0', dc_blocker_xx_0, '0']
- [blocks_complex_to_real_0_0_0, '0', virtual_sink_1_0, '0']
- [blocks_complex_to_real_0_0_0_0, '0', virtual_sink_1_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_real_0_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_xx_1_0, '0', analog_pll_refout_cc_0, '0']
- [blocks_selector_2, '0', blocks_complex_to_mag_0, '0']
- [blocks_selector_2, '1', blocks_multiply_conjugate_cc_0, '0']
- [blocks_selector_2, '1', blocks_multiply_xx_1_0, '0']
- [blocks_selector_2, '1', blocks_multiply_xx_1_0, '1']
- [blocks_selector_2, '2', blocks_complex_to_real_0_0_0, '0']
- [blocks_selector_3_0, '0', low_pass_filter_1, '0']
- [dc_blocker_xx_0, '0', virtual_sink_1, '0']
- [epy_block_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fir_filter_xxx_0, '0', blocks_selector_2, '0']
- [iio_pluto_source_0, '0', blocks_multiply_xx_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_const_vxx_1, '0']
- [virtual_source_1_1_0_0, '0', blocks_selector_3_0, '1']
- [virtual_source_1_1_0_0_0, '0', blocks_selector_3_0, '2']
- [virtual_source_1_1_0_0_1, '0', blocks_selector_3_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
