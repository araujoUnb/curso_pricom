options:
  parameters:
    author: bismark
    generate_options: qt_gui
    id: AM_SDR_TX
    output_language: python
    title: AM SDR TX
  states: {}

blocks:
- name: Ac
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: cut_freq
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: fc
  id: variable
  parameters:
    value: int(1e9)
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    start: '0.2'
    step: '0.1'
    stop: '1.5'
    value: '0.8'
  states: {}
- name: offset
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: plus_freq_vsb
  id: variable
  parameters:
    value: 3e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: select_mensagem
  id: variable_qtgui_chooser
  parameters:
    label: Mensagem a ser enviada
    label0: Musica
    label1: Cosseno
    labels: '[''AM c/ portadora (DSB-TC)'', ''DSB-SC'', ''VSB'', ''SSB'']'
    num_opts: '2'
    option0: '0'
    option1: '1'
    options: '[0, 1, 2, 3]'
    type: int
    value: '0'
  states: {}
- name: set_mod_tx
  id: variable_qtgui_chooser
  parameters:
    label: Tipo de modulacao AM TX
    label0: DSB-LC
    label1: DSB-SC
    label2: VSB
    label3: SSB-USB
    labels: '[''AM c/ portadora (DSB-TC)'', ''DSB-SC'', ''VSB'', ''SSB'']'
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    options: '[0, 1, 2, 3]'
    type: int
    value: '3'
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: tx_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: cut_freq-transition_width
    gain: '20'
    samp_rate: samp_rate*20
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 2e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: cut_freq-transition_width
    low_cutoff_freq: '-plus_freq_vsb+transition_width'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ka
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Ac
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0_1
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: select_mensagem
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '4'
    output_index: set_mod_tx
    type: float
  states: {}
- name: blocks_selector_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: set_mod_tx
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ./audio/rock_mono_48kHz.wav
    repeat: 'True'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '201'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: fc
    samplerate: samp_rate*20
    type: fc32
    uri: uri
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '20'
    taps: tx_taps
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    label1: Mensagem Modulada
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: uri
  id: parameter
  parameters:
    label: URI
    type: str
    value: ip:192.168.1.10
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: DSB-LC_Mod
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: DSB-SC_Mod
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: SSB_Mod
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: VSB_Mod
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: original
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: DSB-LC_Mod
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: DSB-SC_Mod
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: VSB_Mod
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: SSB_Mod
  states: {}

connections:
- [analog_sig_source_x_1, '0', blocks_selector_0, '1']
- [band_pass_filter_0, '0', virtual_sink_0_0_0_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_float_to_complex_0_0, '0', virtual_sink_0, '0']
- [blocks_float_to_complex_0_0_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_0_0_1, '0', virtual_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_null_source_0_0, '0', blocks_float_to_complex_0_0_0, '1']
- [blocks_null_source_0_1, '0', blocks_float_to_complex_0_0_1, '1']
- [blocks_selector_0, '0', blocks_selector_1, '0']
- [blocks_selector_0, '0', virtual_sink_0_1, '0']
- [blocks_selector_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_selector_1, '1', blocks_float_to_complex_0_0_1, '0']
- [blocks_selector_1, '2', blocks_float_to_complex_0_0_0, '0']
- [blocks_selector_1, '3', hilbert_fc_0, '0']
- [blocks_selector_1_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_selector_0, '0']
- [hilbert_fc_0, '0', virtual_sink_0_0_0, '0']
- [interp_fir_filter_xxx_0, '0', iio_pluto_sink_0, '0']
- [virtual_source_0, '0', blocks_selector_1_0, '0']
- [virtual_source_0_0, '0', blocks_selector_1_0, '1']
- [virtual_source_0_0_0, '0', blocks_selector_1_0, '2']
- [virtual_source_0_0_0_0, '0', blocks_selector_1_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
