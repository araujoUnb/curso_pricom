options:
  parameters:
    author: Curso PriCom - UnB
    comment: |-
      Exemplo 02 - Distorcao de Fase
      Um sinal composto por duas senoides passa por um filtro passa-tudo (all-pass) de primeira ordem.
      O filtro NAO altera a magnitude |H(w)|, mas introduz fase nao-linear, causando distorcao de fase.
      Compare as formas de onda no dominio do tempo: a magnitude do espectro e preservada, mas a forma de onda muda!
    description: Exemplo 02 - Distorcao de Fase em Canal LTI
    generate_options: qt_gui
    id: exemplo_02_distorcao_fase
    output_language: python
    title: Exemplo 02 - Distorcao de Fase
  states: {}

blocks:
- name: coef_a
  id: variable
  parameters:
    comment: Coeficiente do filtro all-pass. Valores proximos de 1 causam mais distorcao de fase. H(z) = (a + z^-1)/(1 + a*z^-1) |H(f)| = 1 para todo f, mas fase nao-linear.
    value: '0.9'
  states: {}
- name: freq1
  id: variable
  parameters:
    comment: Primeira componente de frequencia
    value: '500'
  states: {}
- name: freq2
  id: variable
  parameters:
    comment: Segunda componente de frequencia
    value: '1500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Taxa de amostragem
    value: '48000'
  states: {}
- name: blocks_add
  id: blocks_add_xx
  parameters:
    comment: 'Soma: cos(w1*t) + cos(w2*t)'
    type: float
  states: {}
- name: blocks_throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: cos1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Cosseno em freq1 = 500 Hz
    freq: freq1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: cos2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Cosseno em freq2 = 1500 Hz
    freq: freq2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: iir_allpass
  id: iir_filter_ffd
  parameters:
    comment: 'Filtro All-Pass de 1a ordem: fftaps = [a, 1], fbtaps = [1, a] |H(f)| = 1 mas fase nao-linear'
    fbtaps: '[1, coef_a]'
    fftaps: '[coef_a, 1]'
    oldstyle: 'False'
  states: {}
- name: note_info
  id: note
  parameters:
    comment: 'DISTORCAO DE FASE: cos(500Hz) + cos(1500Hz) passa por filtro all-pass. All-pass: |H(f)|=1 mas fase nao-linear. H(z)=(a+z^-1)/(1+a*z^-1). Tempo: forma de onda muda. Frequencia: espectro IGUAL. Azul=original, Vermelho=filtrado.'
    note: Distorcao de Fase
  states: {}
- name: qtgui_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Os espectros de magnitude sao IGUAIS! Isso confirma que o all-pass nao altera |H(f)|.
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: Original
    label2: Apos All-Pass
    name: '"Dominio da Frequencia - Magnitude Preservada"'
    nconnections: '2'
    type: float
    width1: '2'
    width2: '2'
    ymin: '-80'
  states: {}
- name: qtgui_time_sink
  id: qtgui_time_sink_x
  parameters:
    comment: A forma de onda muda mesmo com |H(f)| = 1 (sem distorcao de amplitude)
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: Original
    label2: Apos All-Pass (fase distorcida)
    name: '"Dominio do Tempo - Distorcao de Fase"'
    nconnections: '2'
    size: '2048'
    srate: samp_rate
    type: float
    width1: '2'
    width2: '2'
    ymax: '2.5'
    ymin: '-2.5'
  states: {}

connections:
- [blocks_add, '0', blocks_throttle, '0']
- [blocks_throttle, '0', iir_allpass, '0']
- [blocks_throttle, '0', qtgui_freq_sink, '0']
- [blocks_throttle, '0', qtgui_time_sink, '0']
- [cos1, '0', blocks_add, '0']
- [cos2, '0', blocks_add, '1']
- [iir_allpass, '0', qtgui_freq_sink, '1']
- [iir_allpass, '0', qtgui_time_sink, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
