options:
  parameters:
    author: Curso PriCom - UnB
    comment: |-
      Exemplo 03 - Atraso de Grupo
      Demonstra o conceito de atraso de grupo tau_g(w) = -dphi/dw.
      Tres senoides passam por filtros all-pass em cascata. Cada componente sofre um atraso diferente, mostrando que tau_g varia com a frequencia.
      Para transmissao sem distorcao: tau_g = constante.
    description: Exemplo 03 - Atraso de Grupo em Canal LTI
    generate_options: qt_gui
    id: exemplo_03_atraso_grupo
    output_language: python
    title: Exemplo 03 - Atraso de Grupo
  states: {}

blocks:
- name: coef_a
  id: variable
  parameters:
    comment: Coeficiente do all-pass. Controla a variacao do atraso de grupo. Aumente para ver mais diferenca nos atrasos.
    value: '0.95'
  states: {}
- name: freq1
  id: variable
  parameters:
    comment: Componente de baixa frequencia
    value: '300'
  states: {}
- name: freq2
  id: variable
  parameters:
    comment: Componente de media frequencia
    value: '1200'
  states: {}
- name: freq3
  id: variable
  parameters:
    comment: Componente de alta frequencia
    value: '3500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Taxa de amostragem
    value: '48000'
  states: {}
- name: blocks_add
  id: blocks_add_xx
  parameters:
    comment: Soma das 3 componentes
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: cos1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Cosseno em 300 Hz
    freq: freq1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: cos2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Cosseno em 1200 Hz
    freq: freq2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: cos3
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Cosseno em 3500 Hz
    freq: freq3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: iir_allpass_1
  id: iir_filter_ffd
  parameters:
    comment: All-pass cascata 1 de 4
    fbtaps: '[1, coef_a]'
    fftaps: '[coef_a, 1]'
    oldstyle: 'False'
  states: {}
- name: iir_allpass_2
  id: iir_filter_ffd
  parameters:
    comment: All-pass cascata 2 de 4
    fbtaps: '[1, coef_a]'
    fftaps: '[coef_a, 1]'
    oldstyle: 'False'
  states: {}
- name: iir_allpass_3
  id: iir_filter_ffd
  parameters:
    comment: All-pass cascata 3 de 4
    fbtaps: '[1, coef_a]'
    fftaps: '[coef_a, 1]'
    oldstyle: 'False'
  states: {}
- name: iir_allpass_4
  id: iir_filter_ffd
  parameters:
    comment: All-pass cascata 4 de 4
    fbtaps: '[1, coef_a]'
    fftaps: '[coef_a, 1]'
    oldstyle: 'False'
  states: {}
- name: note_info
  id: note
  parameters:
    comment: 'ATRASO DE GRUPO: tau_g(w)=-dphi/dw. 3 cossenos (300, 1200, 3500 Hz) passam por 4 all-pass em cascata. |H|=1 mas tau_g varia com f. Cada componente sofre atraso diferente. Azul=original, Vermelho=filtrado.'
    note: Atraso de Grupo
  states: {}
- name: qtgui_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Magnitude praticamente igual! A distorcao e apenas no atraso de grupo (fase).
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: Original
    label2: Apos canal
    name: '"Dominio da Frequencia - Magnitude Preservada"'
    nconnections: '2'
    type: float
    width1: '2'
    width2: '2'
    ymin: '-80'
  states: {}
- name: qtgui_time_sink
  id: qtgui_time_sink_x
  parameters:
    comment: Observe como as componentes de frequencia chegam com atrasos diferentes
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: Original
    label2: Apos canal (atraso de grupo variavel)
    name: '"Dominio do Tempo - Efeito do Atraso de Grupo"'
    nconnections: '2'
    size: '2048'
    srate: samp_rate
    type: float
    width1: '2'
    width2: '2'
    ymax: '3.5'
    ymin: '-3.5'
  states: {}

connections:
- [blocks_add, '0', blocks_throttle, '0']
- [blocks_throttle, '0', iir_allpass_1, '0']
- [blocks_throttle, '0', qtgui_freq_sink, '0']
- [blocks_throttle, '0', qtgui_time_sink, '0']
- [cos1, '0', blocks_add, '0']
- [cos2, '0', blocks_add, '1']
- [cos3, '0', blocks_add, '2']
- [iir_allpass_1, '0', iir_allpass_2, '0']
- [iir_allpass_2, '0', iir_allpass_3, '0']
- [iir_allpass_3, '0', iir_allpass_4, '0']
- [iir_allpass_4, '0', qtgui_freq_sink, '1']
- [iir_allpass_4, '0', qtgui_time_sink, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
