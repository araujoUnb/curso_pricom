options:
  parameters:
    author: danie
    generate_options: qt_gui
    id: audio_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\danie\Git\SpeechSignalProcessin\Dataset\Welcome.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: float
  states: {}

connections:
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
